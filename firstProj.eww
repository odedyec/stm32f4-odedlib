<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FirstProj.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\Desktop\STM32F4-Discovery\Project\Peripheral_Examples\TIM_PWM_Output\EWARM\TIM_PWM_Output.ewp</path>
  </project>
  <batchBuild/>
</workspace>


